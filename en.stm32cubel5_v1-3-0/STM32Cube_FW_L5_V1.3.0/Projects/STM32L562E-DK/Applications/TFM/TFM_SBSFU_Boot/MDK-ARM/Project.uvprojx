# Keil uVision project Project.uvprojx, settings and files
target STM32L562E-DK_TFM_SBSFU_Boot (6140000::V6.14::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x080000) IROM2(0x0C000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  BeforeMake: $J\..\bin\armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -DBL2 -I..\..\Linker -I..\Inc ..\Src\image_macros_to_preprocess_bl2.c -o image_macros_preprocessed_bl2.c
  BeforeMake: ..\..\..\..\..\..\Drivers\BSP\Components\ota\abup\bootloader.bat arm_cortexM33_CmiotFotaBL ..\..\..\..\..\..\Drivers\BSP\Components\ota\abup
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L562xx,USE_HAL_DRIVER,NDEBUG,TFM_DEV_MODE,MCUBOOT_TARGET_CONFIG=<flash_layout.h>,MBEDTLS_CONFIG_FILE=<config-boot.h>,MCUBOOT_DOUBLE_SIGN_VERIF,BL2
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Middlewares/Third_Party/trustedfirmware;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common;../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/driver;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/include;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src;../../../../../../Middlewares/Third_Party/mcuboot/ext/tinycrypt/lib/include;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../Linker;../../../../../../Drivers/BSP/STM32L562E-DK;../../../../../../Drivers/BSP/Components/mx25lm51245g;../../../../../../Drivers\BSP\Components\ota\abup\inc;../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/include/flash_map
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x300000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: .\stm32l5xx_bl2.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
--predefine=-DTFM_PSA_API
--entry=Reset_Handler
  group Doc
    ../../: readme.txt
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_cryp.c stm32l5xx_hal_cryp_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_gtzc.c stm32l5xx_hal_hash.c stm32l5xx_hal_hash_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_ospi.c stm32l5xx_hal_otfdec.c stm32l5xx_hal_pka.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_rng_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Drivers/BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery_ospi.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c image_ec.c image_ec256.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group Middlewares/trustedfirmware
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c keys.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/bl2/src/: boot_record.c flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/common/: uart_stdout.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c asn1write.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c hkdf.c md.c md_wrap.c memory_buffer_alloc.c oid.c platform.c platform_util.c rsa.c rsa_internal.c sha256.c
  group Application/User
    ../src/: aes_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c rsa_alt.c low_level_com.c low_level_flash.c low_level_ospi_flash.c system_stm32l5xx.c
    ../Src/: bl2_nv_services.c boot_hal.c low_level_device.c low_level_ospi_device.c low_level_rng.c mpu_armv8m_drv.c sha256_alt.c stm32l5xx_hal_msp.c tfm_bl2_shared_data.c tfm_low_level_security.c
  group Application/MDK-ARM
    ./: startup_stm32l5xx_bl2.s
  group component/abup
    ../../../../../../Drivers/BSP/Components/ota/abup/src/: abup_bl_flash.c abup_bl_main.c abup_hal.c abup_hal_flash.c abup_hal_uart.c
    ../../../../../../Drivers/BSP/Components/ota/abup/lib/bl/: arm_cortexM4_AbupFotaBL.lib
software components: CMSIS:CORE 5.4.0
