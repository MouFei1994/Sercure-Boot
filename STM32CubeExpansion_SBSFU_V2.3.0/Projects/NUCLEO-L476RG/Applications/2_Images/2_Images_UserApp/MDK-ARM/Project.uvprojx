# Keil uVision project Project.uvprojx, settings and files
target STM32L476RG_NUCLEO_2_Images_UserApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . .\#L .\@L.bin 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8094200 size 0x6bc00
  memory RVCT9: RAM 0x20001900 size 0x16400
  scatter file: UserApp.sct
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Doc
    ../: readme.txt
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_crc.c stm32l4xx_hal_flash.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma.c
  group Application/User
    ../Src/: stm32l4xx_it.c fw_update_app.c com.c se_user_code.c flash_if.c main.c common.c test_protections.c ymodem.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/STM32L476RG_NUCLEO_2_Images_SBSFU/: se_interface.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
software components: CMSIS:CORE 4.3.0
