# Keil uVision project Project.uvprojx, settings and files
target STM32WB55RG_Nucleo_2_Images_SECoreBin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32WB55xx,USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,CKS_ENABLED
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32WB/Inc;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\Project.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: hw_ipcc.c se_cks.c se_crypto_bootloader.c se_low_level.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Application/MDK-ARM
    ./: se_key.s
    ./: data_init.c startup_stm32wb55xx_cm4.s
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_pka.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_bootinfo.c se_callgate.c se_crypto_common.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32WB/Lib/: STM32CryptographicV3.0.0_CM4_KEIL_slsm1elfspf.lib
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: shci_tl.c tl_if.c tl_mbox.c
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: stm_list.c
software components: CMSIS:CORE 4.3.0
