# Keil uVision project Project.uvprojx, settings and files
target STM32WB55RG_Nucleo_2_Images_UserApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IRAM_SHARED(0x2002FFFF-0x2002FFFE) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . .\#L .\@L.bin 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32WB55xx,USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\Project.sct
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c com.c common.c fw_update_app.c se_user_code.c test_protections.c ymodem.c flash_if.c stm32wbxx_it.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Drivers/BSP/STM32WBxx_Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_flash.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/STM32WB55RG_Nucleo/Exe/: se_interface_appli.txt
software components: CMSIS:CORE 4.3.0
