# Keil uVision project Project.uvprojx, settings and files
target STM32H753ZI-Nucleo_1_Image_SBSFU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H753ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: SBSFU
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H753xx,USE_STM32H7XX_NUCLEO_144
  c misc: --diag_suppress 1296
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../Core/Inc;../SBSFU/App;../SBSFU/Target;../../1_Image_SECoreBin/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Interface;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: SBSFU.sct
  link misc: --symdefs=se_interface.txt
--keep=SE_CoreBin.o(SE_CORE_Bin)
--diag_suppress L6312W
  group Application/MDK-ARM
    ./: startup_stm32h753xx.s
    ./: SE_CoreBin.s sfu_se_mpu.s
  group Doc
    ../: readme.txt
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level_security.c sfu_low_level_security_rss.c sfu_low_level.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_bootloader.c se_interface_application.c se_interface_common.c
  group Drivers/BSP/stm32h7xx_nucleo_144
    ../../../../../../Drivers/BSP/stm32h7xx_nucleo_144/: stm32h7xx_nucleo_144.c
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_new_image.c sfu_com_loader.c sfu_com_trace.c sfu_fwimg_core.c sfu_boot.c sfu_loader.c sfu_mpu_isolation.c sfu_error.c sfu_test.c sfu_fwimg_services.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Application/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_uart.c stm32h7xx_hal_pwr.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_flash.c stm32h7xx_hal_i2c.c stm32h7xx_hal.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_i2c_ex.c
software components: CMSIS:CORE 4.3.0
