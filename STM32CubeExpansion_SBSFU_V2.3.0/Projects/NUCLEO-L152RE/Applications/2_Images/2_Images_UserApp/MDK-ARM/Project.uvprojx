# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-L152RE_2_Images_UserApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . .\#L .\@L.bin 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L152xE,USE_HAL_DRIVER,USE_STM32L1XX_NUCLEO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  scatter file: Project.sct
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: svc_handler.s
    ./: startup_stm32l152xe.s
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_crc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal.c stm32l1xx_hal_flash.c stm32l1xx_hal_uart.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rtc.c stm32l1xx_ll_fsmc.c stm32l1xx_hal_sram.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/NUCLEO-L152RE/Exe/: se_interface_appli.txt
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/User
    ../Src/: ymodem.c common.c flash_if.c fw_update_app.c com.c mpu.c stm32l1xx_it.c se_user_code.c test_protections.c main.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
software components: CMSIS:CORE 5.1.2
