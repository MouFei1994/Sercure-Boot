# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery_2_Images_UserApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . .\#L .\@L.bin 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: UserApp.sct
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_flash.c stm32l4xx_hal_uart.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_rcc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_sram.c stm32l4xx_ll_fmc.c stm32l4xx_hal.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_i2c.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_io.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/User
    ../Src/: se_user_code.c test_protections.c ymodem.c com.c flash_if.c stm32l4xx_it.c common.c main.c fw_update_app.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/STM32L496G-Discovery_2_Images_SBSFU/: se_interface.txt
software components: CMSIS:CORE 4.3.0
