# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G474RE_1_Image_UserApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\1_Image_SECoreBin\MDK-ARM\postbuild.bat . #L .\@L.bin 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G474xx,USE_HAL_DRIVER,USE_STM32G4XX_NUCLEO,USE_NUCLEO_64
  c include: ../Inc;../../../../../../Drivers/CMSIS/include;../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32G4xx_Nucleo;../../1_Image_SBSFU/SBSFU/App;../SBSFU/Target;../../1_Image_SECoreBin/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: Project.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: fw_update_app.c common.c se_user_code.c test_protections.c main.c flash_if.c stm32g4xx_it.c com.c ymodem.c
  group Drivers/BSP/stm32g4xx_nucleo
    ../../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Middlewares/STM32_Secure_Engine
    ../../1_Image_SBSFU/MDK-ARM/NUCLEO-G474RE/Exe/: se_interface_appli.txt
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_pwr.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_flash.c stm32g4xx_hal_i2c.c stm32g4xx_hal.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_exti.c
software components: CMSIS:CORE 5.0.1
