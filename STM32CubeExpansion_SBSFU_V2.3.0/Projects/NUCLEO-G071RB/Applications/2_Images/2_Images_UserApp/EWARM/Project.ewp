# IAR project Project.ewp, settings and files
configuration NUCLEO-G071RB_2_Images_UserApp (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G071xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32G0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\2_Images_SECoreBin\Inc; ..\..\2_Images_SBSFU\SBSFU\App; ..\..\Linker_Common\EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\UserApp.bin
  postbuild: cmd /C "cmd /C ..\..\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "UserApp.bin" 1"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c com.c common.c fw_update_app.c se_user_code.c test_protections.c ymodem.c flash_if.c stm32g0xx_it.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Drivers/BSP/STM32G0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/EWARM/: se_interface_appli.o
