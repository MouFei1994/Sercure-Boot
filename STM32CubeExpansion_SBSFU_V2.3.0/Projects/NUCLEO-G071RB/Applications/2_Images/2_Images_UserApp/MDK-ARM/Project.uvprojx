# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G071RB_2_Images_UserApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.1.0
  cpu: CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . .\#L .\@L.bin 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32G071xx,USE_STM32G0XX_NUCLEO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32G0xx_Nucleo;../../2_Images_SBSFU/SBSFU/App;../SBSFU/Target;../../2_Images_SECoreBin/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: Project.sct
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: fw_update_app.c common.c se_user_code.c test_protections.c main.c flash_if.c stm32g0xx_it.c com.c ymodem.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/NUCLEO-G071RB/Exe/: se_interface_appli.txt
  group Drivers/BSP/stm32g0xx_nucleo
    ../../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_uart.c stm32g0xx_hal_pwr.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_flash.c stm32g0xx_hal_i2c.c stm32g0xx_hal.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_i2c_ex.c
software components: CMSIS:CORE 4.3.0
