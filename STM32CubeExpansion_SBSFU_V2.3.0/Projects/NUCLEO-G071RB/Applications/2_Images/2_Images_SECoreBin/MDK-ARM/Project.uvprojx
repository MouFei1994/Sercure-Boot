# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G071RB_2_Images_SECoreBin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.1.0
  cpu: CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G071xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32G0xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32G0/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: Project.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Application/MDK-ARM
    ./: data_init.c se_key.s
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: se_low_level.c se_crypto_bootloader.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_bootinfo.c se_callgate.c se_crypto_common.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32G0/Lib/: STM32CryptographicV3.0.0_CM0PLUS_KEIL_slsm1elfspf.lib
software components: CMSIS:CORE 4.3.0
