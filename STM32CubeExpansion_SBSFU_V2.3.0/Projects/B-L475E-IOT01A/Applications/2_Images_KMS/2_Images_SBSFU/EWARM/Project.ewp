# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01_2_Images_SBSFU (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_HAL_DRIVER; USE_STM32L475E_IOT01; KMS_ENABLED
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\Core\Inc; ..\SBSFU\App; ..\SBSFU\Target; ..\..\2_Images_SECoreBin\Inc; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Interface; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\tKMS; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32L4\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "$PROJ_DIR$.\se_interface_appli.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: SE_CORE_Bin
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/Core
    ../Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_loader.c sfu_boot.c sfu_com_loader.c sfu_com_trace.c sfu_error.c sfu_test.c sfu_fwimg_core.c sfu_fwimg_services.c sfu_new_image.c sfu_kms.c sfu_interface_crypto_scheme.c
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level_security.c
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c
  group Middlewares/STM32_Key_Management_Services
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/tKMS/: se_interface_kms.c tkms.c
