# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01_2_Images_SECoreBin (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_HAL_DRIVER; USE_STM32L475E_IOT01; KMS_ENABLED; STSAFE_A100
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Key; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Key_Management_Services\Interface; ..\..\..\..\..\..\Middlewares\ST\STSAFE_A1xx\CoreModules\Inc; ..\..\2_Images_SBSFU\SBSFU\App; ..\..\Linker_Common\EWARM; $PROJ_DIR$; ..\..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Fw_Crypto\STM32L4\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\SE_Core.bin
  prebuild: cmd /C "cmd /C prebuild.bat "$PROJ_DIR$" "
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: SE_CallGate
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: se_low_level.c stsafea_crypto_stlib_interface.c stsafea_service_interface.c stsafe_platf_objects.c kms_ext_token_stsafe.c kms_low_level.c nvms_low_level.c
  group Application/EWARM
    ./: se_key.s startup_stm32l475xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_bootinfo.c se_callgate.c se_crypto_common.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c se_stack_smuggler_IAR.s
  group Middlewares/STSAFE_A1xx/CoreModules
    ../../../../../../Middlewares/ST/STSAFE_A1xx/CoreModules/Src/: stsafea_core.c stsafea_crypto.c stsafea_service.c
  group Middlewares/STM32_Key_Management_Services
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core/: kms_init.c kms_entry.c kms_aes.c kms_digest.c kms_objects.c kms_sign_verify.c kms_dyn_obj.c kms_key_mgt.c kms_nvm_storage.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/: kms_platf_objects.c
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L4/Lib/: STM32CryptographicV3.1.1_CM4_IARv8.a
