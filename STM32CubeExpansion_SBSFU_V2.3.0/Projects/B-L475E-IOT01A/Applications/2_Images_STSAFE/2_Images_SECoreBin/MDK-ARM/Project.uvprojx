# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_2_Images_SECoreBin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01,KMS_ENABLED,STSAFE_A100
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stmpe1600;../../../../../../Drivers/BSP/Components/stmpe811;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface;../../../../../../Middlewares/ST/STSAFE_A1xx/CoreModules/Inc;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L4/Inc;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\SECoreBin.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: se_low_level.c stsafea_crypto_stlib_interface.c stsafea_service_interface.c stsafe_platf_objects.c kms_ext_token_stsafe.c nvms_low_level.c kms_low_level.c
  group Application/MDK-ARM
    ./: se_key.s startup_stm32l475xx.s
    ./: data_init.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_bootinfo.c se_callgate.c se_crypto_common.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c se_stack_smuggler_ARM.s
  group Middlewares/STSAFE_A1xx/CoreModules
    ../../../../../../Middlewares/ST/STSAFE_A1xx/CoreModules/Src/: stsafea_core.c stsafea_crypto.c stsafea_service.c
  group Middlewares/STM32_Key_Management_Services
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core/: kms_init.c kms_entry.c kms_aes.c kms_digest.c kms_objects.c kms_sign_verify.c kms_dyn_obj.c kms_key_mgt.c kms_nvm_storage.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/: kms_platf_objects.c
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L4/Lib/: STM32CryptographicV3.0.0_CM4_KEIL_slsm1elfspf.lib
software components: CMSIS:CORE 4.3.0
