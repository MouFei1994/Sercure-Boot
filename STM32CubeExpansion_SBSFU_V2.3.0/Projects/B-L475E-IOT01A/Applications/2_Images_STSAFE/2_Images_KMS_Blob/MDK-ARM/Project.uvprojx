# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_2_Images_KMS_Blob (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: KMS_Blob
  AfterMake: fromelf #L --bin --output=$L..\..\@L.bin
  AfterMake: postbuild.bat .  $L..\..\@L 1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stmpe1600;../../../../../../Drivers/BSP/Components/stmpe811;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Platform;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L4/Middlewares/ST/STM32_Cryptographic/Inc;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L4/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\KMS_Blob.sct
  link misc: --diag_suppress L6305W
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: kms_blob_example_keys.c
software components: CMSIS:CORE 4.3.0
