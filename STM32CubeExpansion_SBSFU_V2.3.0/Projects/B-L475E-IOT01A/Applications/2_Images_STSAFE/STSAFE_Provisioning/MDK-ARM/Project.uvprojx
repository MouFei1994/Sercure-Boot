# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_STSAFE_Provisioning (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x20017FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01,MBEDTLS_CONFIG_FILE=<config_mbedtls.h>,STSAFE_A100
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stmpe1600;../../../../../../Drivers/BSP/Components/stmpe811;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include/mbedtls;../../../../../../Middlewares/ST/STSAFE_A1xx/CoreModules/Inc;../../../../../../Drivers/BSP/STSAFE_A1xx;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: flash_if.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c stsafea_crypto_mbedtls_interface.c stsafea_service_interface.c system_stm32l4xx.c
  group Application/User/HAL_STSAFE-Axx
    ../Src/: HAL_STSAFE-A100.c HAL_STSAFE-A100_INTERNAL.c Pairing.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/STSAFE_A1xx/CoreModules
    ../../../../../../Middlewares/ST/STSAFE_A1xx/CoreModules/Src/: stsafea_core.c stsafea_crypto.c stsafea_service.c
  group Middlewares/Third_Party/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c cipher.c cipher_wrap.c cmac.c platform.c platform_util.c
software components: CMSIS:CORE 4.3.0
