# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY_2_Images_SBSFU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SBSFU
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY
  c misc: --diag_suppress 1296
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../Core/Inc;../SBSFU/App;../SBSFU/Target;../../2_Images_SECoreBin/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Interface;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: STM32F413H_DISCOVERY_2_Images_SBSFU\SBSFU.sct
  link misc: --symdefs=se_interface.txt
--keep=SE_CoreBin.o(SE_CORE_Bin)
--diag_suppress L6312W
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cortex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32F413H_discovery.c
  group Doc
    ../: readme.txt
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level.c sfu_low_level_security.c
  group Application/Core
    ../Core/Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_mpu_isolation.c sfu_fwimg_services.c sfu_com_loader.c sfu_loader.c sfu_com_trace.c sfu_error.c sfu_test.c sfu_new_image.c sfu_fwimg_core.c sfu_boot.c
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s sfu_se_mpu.s
    ./: SE_CoreBin.s
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_common.c se_interface_bootloader.c se_interface_application.c
software components: CMSIS:CORE 4.3.0
